# IAR project mksDLP.ewp, settings and files
configuration mksDLP (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; STM32F40_41xxx; USE_HAL_LIB; MKS_DLP_BOARD; TFT35; USE_STM32F407VET
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../Inc; ../Src; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src/drivers; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/Marlin; ../Drivers/CMSIS/Include; ../Drivers/BSP/variant; ../Drivers/BSP/Components/at24cxx; ../Drivers/BSP/Components/w25qxx; ../Drivers/BSP/Components/ssd2828; ../Drivers/BSP/Components/lcd; ../Drivers/libstmf4; ../Drivers/libstmf4/include; ../Middlewares/arduino/stm32/cores/arduino; ../User/ui; ../User/ui/Multi_language; ../User/ui/QRENCODE; ../Middlewares/GUI
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: mksDLP.bin
  ILINK.IlinkOutputFile: mksDLP.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Middlewares/gui/: mksDLP.a
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Application/User
    ../Src/: bsp_driver_sd.c dma.c fatfs.c fsmc.c gpio.c i2c.c ili9320.c iwdg.c main.cpp mks_cfg.cpp mks_test.cpp mks_touch_screen.c pic.c pic_manager.cpp rtc.c sdio.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.cpp string_deal.c tim.c usart.c usb_host.c usbh_conf.c wifi_module.cpp wifi_upload.cpp
  group Application/User/QRENCODE
    ../User/ui/QRENCODE/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
  group Application/User/UI
    ../User/ui/: draw_about.cpp draw_bind.cpp draw_change_speed.cpp draw_clean.cpp draw_detection.cpp draw_dialog.cpp draw_disk.cpp draw_ExposureTest.cpp draw_extrusion.cpp draw_fan.cpp draw_filamentchange.cpp draw_FileTransfer_ui.cpp draw_info.cpp draw_keyboard.cpp draw_language.cpp draw_manual_leveling.cpp draw_mesh_leveling.cpp draw_more.cpp draw_move_motor.cpp draw_operate.cpp draw_pre_heat.cpp draw_preview.cpp draw_print_file.cpp draw_printing.cpp draw_printing_moremenu.cpp draw_ready_print.cpp draw_service.cpp draw_set.cpp draw_tool.cpp draw_ui.cpp draw_wifi.cpp draw_zero.cpp id_manage.c
    ../User/ui/Multi_language/: Font24_MS.c multi_language.cpp
    ../Src/: mks_fontHz14.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/at24cxx/: at24cxx.cpp
    ../Drivers/BSP/Components/w25qxx/: spi_flash.c
    ../Drivers/BSP/Components/SSD2828/: ssd2828.cpp
  group Drivers/BSP/variant
    ../Drivers/BSP/variant/: mks_variant.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/libstmf4
    ../Drivers/libstmf4/source/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Middlewares/Arduino
    ../Middlewares/arduino/stm32/cores/arduino/: Print.cpp RingBuffer.cpp Stream.cpp USARTClass.cpp WMath.cpp WString.cpp
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: mycc936.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c usbh_diskio.c
  group Middlewares/Marlin
    ../Middlewares/Third_Party/Marlin/: blinkm.cpp cardreader.cpp configuration_store.cpp dac_mcp4728.cpp digipot_mcp4451.cpp endstops.cpp G26_Mesh_Validation_Tool.cpp gcode.cpp hex_print_routines.cpp least_squares_fit.cpp M100_Free_Mem_Chk.cpp Marlin_main.cpp MarlinSerial.cpp mesh_bed_leveling.cpp planner.cpp planner_bezier.cpp printcounter.cpp serial.cpp servo.cpp stepper.cpp stepper_dac.cpp stepper_indirection.cpp stopwatch.cpp temperature.cpp twibus.cpp ubl.cpp ubl_G29.cpp ubl_motion.cpp utility.cpp vector_3.cpp watchdog.cpp
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
